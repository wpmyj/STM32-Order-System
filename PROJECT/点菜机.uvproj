# Keil uVision project 点菜机.uvproj, settings and files
target 点菜机 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 点菜机 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\SYS;..\SYSTEM\SYS_Init_3.5;..\SYSTEM\SYS_Init_3.5\inc;..\SYSTEM\SYS_Init_3.5\src;..\SYSTEM\LED;..\SYSTEM\Beep;..\SYSTEM\KEY;..\SYSTEM\Delay;..\SYSTEM\SPI;..\SYSTEM\W25Q64;..\SYSTEM\USART;..\SYSTEM\LCD;..\SYSTEM\Fonts;..\SYSTEM\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group SYS_Init
    ../SYSTEM/SYS_Init_3.5/: system_stm32f10x.c core_cm3.c startup_stm32f10x_hd.s
  group CMSIS
    ../SYSTEM/SYS_Init_3.5/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/SYS/: SYS.c
    ../SYSTEM/LED/: LED.c
    ../SYSTEM/Beep/: Beep.c
    ../SYSTEM/KEY/: KEY.c
    ../SYSTEM/Delay/: delay.c
    ../SYSTEM/SPI/: SPI.c
    ../SYSTEM/W25Q64/: W25Q64.c
    ../SYSTEM/USART/: USART.c
    ../SYSTEM/LCD/: ILI9341.c
    ../SYSTEM/Fonts/: Font.c
    ../SYSTEM/RTC/: RTC.c
  group USER
    ../USER/: main.c Application.c Login.c Home.c Readme.txt
